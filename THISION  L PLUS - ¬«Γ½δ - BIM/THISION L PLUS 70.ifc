Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-06-30T13:30:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 30 13:30:18 2020 * Host: CRAICA-RO-DE * Database: C:\Users\CRaica\AppData\Local\Temp\{CDFB9518-0BA7-4EFE-BE8B-9B37ED88CFD0}\ifc * Database version: 5507 * Database creation date: Tue Jun 30 13:30:18 2020 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Jun 30 13:30:18 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 30 13:30:18 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcBoiler: THISION L PLUS 70, HC_Boiler_MEPcontent_Elco_THISION L PLUS 70_INT-EN:THISION L PLUS 70:10200
In: Level 1
Type - PredefinedType: WATER; Material: Color RGB 049-049-049, Color RGB 216-216-216, Color RAL 9016, Color RGB 172-184-196
Type - Dimensions - Depth: 590 mm; Drain Diameter: 32 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 28.6 mm; Height: 1050 mm; Hydronic Return Diameter: 45 mm; Hydronic Supply Diameter: 45 mm; Supply Air Diameter: 100 mm; Use Nominal Diameter: yes; Width: 530 mm
Type - Electrical - Electrical Connection: 230 V; Frequency: 50 Hz; Hertz: 50 Hz; IP Class: IPX4D; Mains Connection Fuse: 6.3 A; Phase: 1; Power Consumption Boiler max ErP (Incl. Pump): 137 W; Power Consumption Boiler min ErP (Incl. Pump): 45 W; Voltage: 230 V
Type - General - CE Certification Code: 0063CT3449; Maximum Gas Pressure: 5750000000 Pa; Min Gas Pressure H-gas: 1700000000 Pa; Min Gas Pressure L-gas: 2000000000 Pa; Min Gas Pressure LPG (mbar): 25-35; Minimum Heat Input Hi min: 14900 W; Minimum Heat Output at 40/30ºC: 16200 W; Minimum Heat Output at 50/30ºC: 16100 W; Minimum Heat Output at 75-60ºC: 14700 W; Minimum Heat Output at 80-60ºC: 14700 W; Modulation: 4; Noise Level (dB(A)): 65; Nominal Heat Input Hi max: 66700 W; Nominal Heat Output at 40/30ºC: 72100 W; Nominal Heat Output at 50/30ºC: 71900 W; Nominal Heat Output at 75-60ºC: 65400 W; Nominal Heat Output at 80-60ºC: 65400 W; Sound Pressure Level (dB(A)): 54; Weight (empty): 73
Type - Identity Data - Article Description: Boiler 70kW wall hung; Article Type: THISION L PLUS 70; Base Family Version: 12.15; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Boiler 70kW wall hung; EMCS Version: 4.0; ETIM Article Class: EC011396; Family Version: 12.09; Manufacturer: Elco; Manufacturer URL: http://www.elco.net/; MEPcontent Class: BOILER; Model: THISION L PLUS 70; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: Elco; Revit Version: 2018; Type Name: THISION L PLUS 70; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Black: Color RGB 049-049-049; Light Grey: Color RGB 172-184-196; Light White: Color RAL 9016; White: Color RGB 216-216-216
Type - Mechanical - Hydraulic Resistance at Nominal Water Flow: 24300 Pa; Hydraulic Resistance at Nominal Water Flow (dT 25K): 15600 Pa; Max. Condensate (full load @ 40/30ºC, 20ºC ambient, G20): 0.254266 m3/s; Max. Permissible Flue Resistance max: 156 Pa; Maximum Available Head for System: 14800 Pa; Maximum Temperature Setpoint: 90 kg/K/s3; Maximum Water Temperature (High Limit Thermostat): 95 kg/K/s3; Nominal Power 50-30°C: 0; Nominal Power 80-60°C: 0; Nominal Water Flow at dT=20K: 0.0284479 m3/s; Nominal Water Flow at dT=25K: 0.0225621 m3/s; NOx Class: 6; Tap Capacity at 60°C: 0 m3/s; Total Head at Nominal Flow: 39100 Pa; Volume: 0 m3; Water Pressure max: 600000 Pa; Water Pressure min: 70000 Pa; Water Volume: 0.0093 m3; ΔT max (K): 30
Type - Other - Category: Mechanical Equipment; Family Name: HC_Boiler_MEPcontent_Elco_THISION L PLUS 70_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: Elco
Constraints - Offset: 0 mm
Dimensions - Area: 1.56044 m2; Volume: 0.338275 m3
Electrical - Power: 137 W
Identity Data - Mark: 1
Mechanical - System Classification: Supply Air,Undefined,Power,Hydronic Return,Hydronic Supply,Sanitary,Other
Mechanical - Flow - Drain Fixture Units: 0; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Family: HC_Boiler_MEPcontent_Elco_THISION L PLUS 70_INT-EN: THISION L PLUS 70; Family and Type: HC_Boiler_MEPcontent_Elco_THISION L PLUS 70_INT-EN: THISION L PLUS 70; Type: HC_Boiler_MEPcontent_Elco_THISION L PLUS 70_INT-EN: THISION L PLUS 70; Type Id: HC_Boiler_MEPcontent_Elco_THISION L PLUS 70_INT-EN: THISION L PLUS 70
Phasing - Phase Created: New Construction
